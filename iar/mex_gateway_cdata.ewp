# IAR project mex_gateway_cdata.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mex_gateway_cdata.srec
  postbuild: "stf4_postBuild.bat" "bin" "$TOOLKIT_DIR$" "$TARGET_PATH$" 0x08010000 0x0803FFFF
  ILINK.IlinkOutputFile: mex_gateway_cdata.out
  ILINK.IlinkIcfFile: stf4_cdata.icf
  ILINK.IlinkProgramEntryLabel: cd_CONSTANT_DATA
  group (top)
    ../sources/bsp/: iar_cdata.c
