<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\mex_gateway.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\mex_gateway_cdata.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\mex_gateway_ecuid.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>Debug_Simulation</name>
            <member>
                <project>mex_gateway</project>
                <configuration>DebugSIM</configuration>
            </member>
            <member>
                <project>mex_gateway_cdata</project>
                <configuration>DebugSIM</configuration>
            </member>
            <member>
                <project>mex_gateway_ecuid</project>
                <configuration>DebugSIM</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>Release_Simulation</name>
            <member>
                <project>mex_gateway</project>
                <configuration>ReleaseSIM</configuration>
            </member>
            <member>
                <project>mex_gateway_cdata</project>
                <configuration>ReleaseSIM</configuration>
            </member>
            <member>
                <project>mex_gateway_ecuid</project>
                <configuration>ReleaseSIM</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>Debug_Hardware</name>
            <member>
                <project>mex_gateway</project>
                <configuration>DebugHW</configuration>
            </member>
            <member>
                <project>mex_gateway_cdata</project>
                <configuration>DebugHW</configuration>
            </member>
            <member>
                <project>mex_gateway_ecuid</project>
                <configuration>DebugHW</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>Release_Hardware</name>
            <member>
                <project>mex_gateway</project>
                <configuration>ReleaseHW</configuration>
            </member>
            <member>
                <project>mex_gateway_cdata</project>
                <configuration>ReleaseHW</configuration>
            </member>
            <member>
                <project>mex_gateway_ecuid</project>
                <configuration>ReleaseHW</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>mex_gateway_ecuid</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>mex_gateway_cdata</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>mex_gateway</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>mex_gateway</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
