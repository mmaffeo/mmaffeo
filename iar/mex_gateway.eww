<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\mex_gateway.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\mex_gateway_cdata.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\mex_gateway_ecuid.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>Debug</name>
            <member>
                <project>mex_gateway_ecuid</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>mex_gateway_cdata</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>mex_gateway</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>Release</name>
            <member>
                <project>mex_gateway_ecuid</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>mex_gateway_cdata</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>mex_gateway</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>All</name>
            <member>
                <project>mex_gateway_ecuid</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>mex_gateway_cdata</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>mex_gateway</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>mex_gateway</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
