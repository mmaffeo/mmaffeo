# IAR project mex_gateway_ecuid.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mex_gateway_ecuid.srec
  postbuild: "stf4_postBuild.bat" "bin" "$TOOLKIT_DIR$" "$TARGET_PATH$" 0x08008000 0x0800BFFF
  ILINK.IlinkOutputFile: mex_gateway_ecuid.out
  ILINK.IlinkIcfFile: stf4_ecuid.icf
  ILINK.IlinkProgramEntryLabel: ecuid
  group (top)
    ../sources/bsp/: m4ecuid.c
