# IAR project mex_gateway.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG=1; HW_NVM_FAKE_MANUFACTURING_DATA=1; BOOTLOADER=0; USE_FULL_ASSERT=1; STM32F40_41xxx=1; USE_STDPERIPH_DRIVER=1; HSE_VALUE=((uint32_t)10000000); HCS12_BSP_EMU=1; PORTABLE_WORDSIZES=1; FALSE=false; TRUE=true; far=
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\Sources; ..\Sources\bsp; ..\lib\bsp\lib\hw_hcs12\inc; ..\lib\bsp\lib\hw_hcs12\src; ..\lib\bsp\lib\hw_hcs12\src\emuBSP; ..\lib\bsp\inc; ..\lib\bsp\inc\m4; ..\lib\bsp\src\stf4; ..\lib\bsp\lib\cmsis; ..\lib\bsp\lib\stm32f4xx_stdperiph\inc; ..\lib\bsp\lib\stm32f4xx_stdperiph\src; ..\model\functions; ..\model\MX_Gtwy_Control_bobcat_ert_rtw; ..\lib\CANOpen\inc; ..\lib\CANOpen\src; C:\Projects\SVNrepo\dibh-prod-esEMex\lib\CANStd\inc; C:\Projects\SVNrepo\dibh-prod-esEMex\lib\CANStd\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: mex_gateway.srec
  postbuild: "stf4_postBuild.bat" "bin" "$TOOLKIT_DIR$" "$TARGET_PATH$" 0x08040000 0x080FFFFF
  ILINK.IlinkOutputFile: $PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkIcfFile: stf4_app.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HW_NVM_FAKE_MANUFACTURING_DATA=0; BOOTLOADER=0; USE_FULL_ASSERT=0; STM32F40_41xxx=1; USE_STDPERIPH_DRIVER=1; HSE_VALUE=((uint32_t)10000000); HCS12_BSP_EMU=1; PORTABLE_WORDSIZES=1; FALSE=false; TRUE=true; far=
  ICCARM.CCOptLevel: 3
  group (top)
    ../sources/: af_main.h ap_bservice.cpp ap_bservice.h ap_bservice_CAN04.cpp ap_bservice_CAN04.h ap_bservice_dv.cpp ap_bservice_dv.h ap_bservice_prog.cpp ap_bservice_prog.h ap_can.cpp ap_can.h ap_deluxeG5.cpp ap_deluxeG5.h ap_deluxeG55.cpp ap_deluxeG55.h ap_dv.cpp ap_dv.h ap_eeprom.cpp ap_eeprom.h ap_engine.cpp ap_engine.h ap_gateway.cpp ap_gateway.h ap_hwt.cpp ap_hwt.h ap_keylessentry.cpp ap_keylessentry.h ap_keylessstart.cpp ap_keylessstart.h ap_main.cpp ap_main.h ap_MXGWcontrol_defs.h ap_subs.cpp ap_subs.h ap_tasks.cpp ap_tasks.h ap_version.cpp ap_version.h cancipher.cpp cancipher.h defines.h global.cpp global.h hw_can_cfg.h passwordverifier.cpp passwordverifier.h
    ../sources/bsp/: ap.cpp ap.h ap_bsp.cpp ap_bsp.h ap_cdata.cpp ap_cdata.h ap_eeprom_bsp.cpp ap_schd.cpp ap_schd.h cdata.h main.cpp
    ../lib/CANOpen/src/: ap_bservice_CANOpen.cpp
    ../lib/CANOpen/inc/: ap_bservice_CANOpen.h
    ../lib/CANStd/src/: ap_bservice_CANStd.cpp
    ../lib/CANStd/inc/: ap_bservice_CANStd.h
  group bsp
    ../lib/bsp/inc/: bsp_adc.h bsp_can.h bsp_clock.h bsp_com.h bsp_common.h bsp_din.h bsp_dout.h bsp_ecuid.h bsp_fin.h bsp_mcu.h bsp_nvm.h bsp_pwm.h bsp_rom.h bsp_rtc.h bsp_sdata.h
    ../lib/bsp/inc/m4/: bsp_types.h
    ../lib/bsp/src/stf4/: iar_stf4_cstartup.c stf4_bsp_adc.c stf4_bsp_adc.h stf4_bsp_can.c stf4_bsp_can.h stf4_bsp_clock.c stf4_bsp_clock.h stf4_bsp_com.c stf4_bsp_com.h stf4_bsp_din.c stf4_bsp_din.h stf4_bsp_dout.c stf4_bsp_dout.h stf4_bsp_ecuid.c stf4_bsp_ecuid.h stf4_bsp_fin.c stf4_bsp_fin.h stf4_bsp_mcu.c stf4_bsp_mcu.h stf4_bsp_nvm.c stf4_bsp_nvm.h stf4_bsp_pwm.c stf4_bsp_pwm.h stf4_bsp_rom.c stf4_bsp_rom.h stf4_bsp_rtc.c stf4_bsp_rtc.h stf4_bsp_sdata.c stf4_bsp_sdata.h stf4_cstartup.h stf4_fifo.c stf4_fifo.h stf4_iic.c stf4_iic.h stf4_timer.c stf4_timer.h stf4_vectors.c stf4_vectors.h stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c system_stm32f4xx.h
  group bsp/cmsis
    ../lib/bsp/lib/cmsis/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group bsp/StdPeriph
    ../lib/bsp/lib/stm32f4xx_stdperiph/src/: stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_tim.c stm32f4xx_usart.c
    ../lib/bsp/lib/stm32f4xx_stdperiph/inc/: stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_dma.h stm32f4xx_gpio.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rtc.h stm32f4xx_tim.h stm32f4xx_usart.h
  group hw
    ../lib/bsp/lib/hw_hcs12/inc/: Hw_adc.h hw_can.h hw_can_msg.h hw_can_rx.h hw_can_tx.h hw_can_txq.h hw_clock.h Hw_dio.h hw_fin.h hw_fps.h hw_gauge.h hw_io.h hw_io_GetSet.h hw_mcu.h hw_nvm.h hw_pwm.h hw_reset.h hw_timer.h J1939_msg.h J1939_TP.h J1939_TP_rx.h J1939_TP_tx.h nvm_ecuid.h
    ../lib/bsp/lib/hw_hcs12/src/: hw_can_rx.cpp hw_can_tx.cpp hw_can_txq.cpp hw_gauge.cpp hw_timer.cpp J1939_msg.cpp J1939_TP.cpp J1939_TP_rx.cpp J1939_TP_tx.cpp
  group hw/emuBSP
    ../lib/bsp/lib/hw_hcs12/src/emuBSP/: hw_adc.cpp hw_can.cpp hw_clock.cpp hw_dio.cpp hw_fin.cpp hw_io.cpp hw_mcu.cpp hw_nvm.cpp hw_pwm.cpp nvm_ecuid.cpp
  group model
    ../model/MX_Gtwy_Control_bobcat_ert_rtw/: mod_Inputs.cpp mod_Inputs.h mod_Library.cpp mod_Library.h mod_Outputs.cpp mod_Outputs.h mod_Panel.cpp mod_Panel.h mod_System.cpp mod_System.h MX_Gtwy_Control.cpp MX_Gtwy_Control.h MX_Gtwy_Control_data.cpp MX_Gtwy_Control_private.h MX_Gtwy_Control_types.h rtmodel.h rtwtypes.h
    ../model/functions/: SendMsgNow.cpp SendMsgNow.h
